Commit message: 把mujoco仿真写成ros节点

File: src/so_arm101_description/urdf/so_arm101.urdf (robot description, URDF)
Before this commit: robot so101, 8 links, 7 joints
Joints:
- joint shoulder_pan: axis 0 0 1 -> 0 0 -1
